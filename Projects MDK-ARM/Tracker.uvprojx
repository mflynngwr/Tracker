# Keil uVision project Tracker.uvprojx, settings and files
target Tracker (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F301C6 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Tracker
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F301x8
  c misc: --C99
  c include: ../Inc;C:/Users/Mark/Development/Pivot/Tracker/ThirdParty/Libs/STM32Cube_FW_F3_V1.9.0/Drivers/STM32F3xx_HAL_Driver/Inc;C:/Users/Mark/Development/Pivot/Tracker/ThirdParty/Libs/STM32Cube_FW_F3_V1.9.0/Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;C:/Users/Mark/Development/Pivot/Tracker/ThirdParty/Libs/STM32Cube_FW_F3_V1.9.0/Drivers/CMSIS/Device/ST/STM32F3xx/Include;C:/Users/Mark/Development/Pivot/Tracker/ThirdParty/Libs/STM32Cube_FW_F3_V1.9.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329 ..\Output\STM32CubeLib\STM32CubeLib.lib
  group Application/Tracker
    ../Src/: Tracker.c Tracker_if.c Tracker_MotorCtl.c
  group Application/STM32
    ../Src/: stm32f3xx_tracker.c stm32f3xx_motorctl.c stm32f3xx_hal_msp.c stm32f3xx_it.c stm32f3xx_if.c
  group Application/MDK-ARM
    ../Src/: startup_stm32f301x8.s
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
software components: CMSIS:CORE 4.1.0
