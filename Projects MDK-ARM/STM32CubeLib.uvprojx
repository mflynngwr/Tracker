# Keil uVision project STM32CubeLib.uvprojx, settings and files
target F3xxHalLib (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F301C6 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32CubeLib (library)
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F301x8,USE_HAL_DRIVER,HAL_MODULE_ENABLED
  c misc: --echo
  c include: ..\Inc;..\ThirdParty\Libs\STM32Cube_FW_F3_V1.9.0\Drivers\STM32F3xx_HAL_Driver\Inc;..\ThirdParty\Libs\STM32Cube_FW_F3_V1.9.0\Drivers\CMSIS\Device\ST\STM32F3xx\Include;..\ThirdParty\Libs\STM32Cube_FW_F3_V1.9.0\Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source
    ../ThirdParty/Libs/STM32Cube_FW_F3_V1.9.0/Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_sram.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c
